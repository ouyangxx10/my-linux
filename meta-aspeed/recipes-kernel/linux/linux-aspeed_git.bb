#KBRANCH ?= "dev-4.18"
KBRANCH ?= "video-dev"
#LINUX_VERSION ?= "4.18.16"
LINUX_VERSION ?= "4.18"

#SRCREV="ac3d5d4192df9eeeb513cc2a6259718335a4f569"
SRCREV="b953727d56c4de63eb0fad1f079f41004e61d713"

require linux-aspeed.inc
